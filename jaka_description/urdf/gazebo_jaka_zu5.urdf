Commit message: add moveit_arm_control

File: jaka_description/urdf/gazebo_jaka_zu5.urdf (robot description, URDF)
Before this commit: robot jaka_zu5, 11 links, 10 joints
Joints:
- joint fixed: origin xyz=0 0 0.5 rpy=0 0 0 -> xyz=0 0 0.85 rpy=0 0 0
